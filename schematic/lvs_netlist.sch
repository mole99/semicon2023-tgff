v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/leo/Nextcloud/Programmieren/ASIC/Semicon2023_D-FF/d-ff/d-ff.sym} -10 20 0 0 {name=x1}
C {/home/leo/Nextcloud/Programmieren/ASIC/Semicon2023_D-FF/d-ff/floating_devices.sym} 290 0 0 0 {name=x2}
